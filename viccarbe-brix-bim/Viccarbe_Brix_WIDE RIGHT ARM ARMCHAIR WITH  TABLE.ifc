Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-05-04T16:00:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 04 16:00:23 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{500B02B2-219E-4566-9A17-30E7851BA224}\ifc * Database version: 5507 * Database creation date: Wed May 04 16:00:22 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 04 16:00:22 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 04 16:00:23 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: WIDE RIGHT ARM ARMCHAIR WITH TABLE, 2015_Armchair_Viccarbe_Brix:WIDE RIGHT ARM ARMCHAIR WITH TABLE:130961
In: Nivel 1
Type - ElementType: WIDE RIGHT ARM ARMCHAIR WITH TABLE; Material: Steel, Paint Finish, White, Linen - Violet blue
Type - Construction - Table Left: no; Table Right: yes
Type - Dimensions - Depth (inches): 23.62"; Depth (mm): 600 mm; Height (inches): 26.37"; Height (mm): 670 mm; Width (inches): 45.66"; Width (mm): 1160 mm
Type - Identity Data - Bimetica: http://www.bimetica.com/; Collection: BRIX; Content Revision Date: 28/04/2016; Created by: Bimetica Parametric Design Services, S.L.; Description: Thanks to its geometric design, many units can be grouped together to create elegant configuration. Its arms in different and very closely researched sizes mean that you can work on your tablet on the wide arm and even have an auxiliary table with a built-in support. A new version is now available with two thin arms for smaller spaces.; Designer: KENSAKU OSHIRO; Essays UNE: http://www.viccarbe.com/archivos/viccarbe-test-brix-56.pdf; General Dimensions (inches): 26.37"x45.66"x23.62"; General Dimensions (mm): 670x1160x600 mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: WIDE ARM ARMCHAIR WITH TABLE; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=35516688a565c62ç; Reference Code: BRIX + BRIM; Technical information: http://www.viccarbe.com/archivos/viccarbe-brix-en-info-62.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: WIDE RIGHT ARM ARMCHAIR WITH TABLE; URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Base Material: Steel, Paint Finish, White; Materials - Fabrics: http://www.viccarbe.com/archivos/VICCARBE_Kvadrat_fabrics.pdf; Materials - Lacquers: http://www.viccarbe.com/archivos/VICCARBE_lacquers_lacados.pdf; Materials - Leather: http://www.viccarbe.com/archivos/VICCARBE_leather.pdf; Materials - Vinyl: http://www.viccarbe.com/archivos/VICCARBE_polipiel_vinyl.pdf; Seat Material: Linen - Violet blue; Table Material: Steel, Paint Finish, White
Type - Other - Category: Furniture; Arm Left Width (mm): 65 mm; Arm Right Width (mm): 295 mm; Family Name: 2015_Armchair_Viccarbe_Brix; Seat Height (mm): 410 mm
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Armchair_Viccarbe_Brix: WIDE RIGHT ARM ARMCHAIR WITH TABLE; Tipo: 2015_Armchair_Viccarbe_Brix: WIDE RIGHT ARM ARMCHAIR WITH TABLE; Descripción: Thanks to its geometric design, many units can be grouped together to create elegant configuration. Its arms in different and very closely researched sizes mean that you can work on your tablet on the wide arm and even have an auxiliary table with a built-in support. A new version is now available with two thin arms for smaller spaces.; Fabricante: VICCARBE; Modelo: WIDE ARM ARMCHAIR WITH TABLE; URL: http://www.viccarbe.com/
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.92975 m2; Volume: 0.147471 m3
Other - Family: 2015_Armchair_Viccarbe_Brix: WIDE RIGHT ARM ARMCHAIR WITH TABLE; Family and Type: 2015_Armchair_Viccarbe_Brix: WIDE RIGHT ARM ARMCHAIR WITH TABLE; Type: 2015_Armchair_Viccarbe_Brix: WIDE RIGHT ARM ARMCHAIR WITH TABLE; Type Id: 2015_Armchair_Viccarbe_Brix: WIDE RIGHT ARM ARMCHAIR WITH TABLE
Phasing - Phase Created: Fase 1
